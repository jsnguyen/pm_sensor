# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c gp2y1010au.c arm_cortex_m.c
    ../User/SysTick/: systick.c
    ../User/USART/: usart.c
  group StdPeriph_Driver
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_usart.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group Readme
    ../: Readme.txt
